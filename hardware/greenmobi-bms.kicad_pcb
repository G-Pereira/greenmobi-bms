# Repository G-Pereira/greenmobi-bms

File README.md:

# GreenMobi BMS - A BMS board compatible with the VESC BMS firmware

The [VESC BMS board system is under closed development](https://vesc-project.com/node/311) at the time of this writing although the BMS firmware is publicly available so this project consists on a VESC compatible BMS board that is able to run [VESC BMS firmware](https://github.com/vedderb/vesc_express).

This project is under development and the board is not yet ready. [KiCAD](https://www.kicad.org/) is being used for the board's design and contributions are welcome.

[**Join us on discord**](https://discord.gg/AxKemSxhaV)

## Desing approach

Since there is not yet a opensource design of a VESC fully compatible BMS this board is being designed with ease of development in mind so it can be used as a reference design to contribute directly to the VESC project and extend its potential. So the following principles are followed:

- Popular and easy to source connectors are used (JST PH, screw terminals, etc) even if in most end uses it would be better to have weatherproof panel connectors.
- SMD packages optimized for JLC assembly or PnP on premises (down to 0402 passives).
- Up to 32S supported

Here it is a block diagram of the design:

## Contributions

Since the design is at a schematic phase, it would be helpful if you can review the board's schematic to look for misconnections and erros using any of the given ICs. However, any other kind of productive feedback and work is welcome. Be sure to read the [design approach](#desing-approach) so your contributions match the goals of the project.

### Schematic PDF

To get the latest PDF version of the shematic go to GitHub Actions and download the artifacts of the latest workflow run.

## Credits

This project is meant to be interoperable with the VESC, which is a [registred trademark](https://vesc-project.com/trademark_policies), held by Benjamin Vedder and the BMS firmware and its hardware design hints that are in it that this designs follows are of Benjamin Vedder's authoring.

## KiCad design hardware/greenmobi-bms.kicad_pcb

Parts:
C1: 100n; C_0402_1005Metric
F1: 20A; Fuse_Littelfuse-NANO2-451_453; LCSC C178980
H1: BAT+; SolderWire-2sqmm_1x01_D2mm_OD3.9mm
H2, H6, H7, H8: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
H3: BAT-; SolderWire-2sqmm_1x01_D2mm_OD3.9mm
H4: CHG+; SolderWire-2sqmm_1x01_D2mm_OD3.9mm
H5: CHG-; SolderWire-2sqmm_1x01_D2mm_OD3.9mm
J1: EN; JST_GH_SM02B-GHS-TB_1x02-1MP_P1.25mm_Horizontal
J2: USB; USB_C_Receptacle_Palconn_UTC16-G
J3: CAN; JST_GH_SM02B-GHS-TB_1x02-1MP_P1.25mm_Horizontal
R1, R2, R3: 5.1k; R_0402_1005Metric
R4: 120; R_0402_1005Metric
U1: TJA1042T-3; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C132227

Connections:
+3.3V: R1.2, U1.5 (VIO); also elsewhere on the board
+5V: U1.3 (VCC); also elsewhere on the board
/BAT+: F1.1, H1.1
/CAN+: J3.2, R4.1, U1.7 (CANH)
/CAN-: J3.1, R4.2, U1.6 (CANL)
/Frontend/BAT+: F1.2; also elsewhere on the board
/Frontend/BAT-: H3.1; also elsewhere on the board
/Frontend/CHG+: H4.1; also elsewhere on the board
/Frontend/CHG-: H5.1; also elsewhere on the board
/Frontend/Shutdown: C1.1, J1.1, R1.1; also elsewhere on the board
/MCU/CAN_RX: U1.4 (RXD); also elsewhere on the board
/MCU/CAN_TX: U1.1 (TXD); also elsewhere on the board
/MCU/~COM_EN: U1.8 (STB); also elsewhere on the board
/USB_DN: J2.A6 (D+), J2.B6 (D+); also elsewhere on the board
/USB_DP: J2.A7 (D-), J2.B7 (D-); also elsewhere on the board
GND: C1.2, H2.1, H6.1, H7.1, H8.1, J1.2, J1.MP (MountPin), J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), J3.MP (MountPin), R2.2, R3.2, U1.2 (GND); also elsewhere on the board
unnamed: J2.A5 (CC1), R2.1
unnamed: J2.B5 (CC2), R3.1

Notes on the sheet:
Data and flash
Communication
CAN
Enable
USB
Switch (key)

Parts:
C27: 470n; C_0603_1608Metric
C28, C32, C33, C34, C35, C36, C37, C38, C39, C40, C41, C42, C43, C44, C45, C46, C47, C48: 100n; C_0402_1005Metric
C29: 2.2u; C_0603_1608Metric
C30: 100p; C_0603_1608Metric
C31: 1u; C_1206_3216Metric
C49, C50: 100n; C_1206_3216Metric; LCSC C1945
D1: BZT52Bxx; D_SOD-123F
J4, J5: EXT_NTC; JST_GH_SM02B-GHS-TB_1x02-1MP_P1.25mm_Horizontal
J6: Conn_01x17_MountingPin; JST_GH_SM17B-GHS-TB_1x17-1MP_P1.25mm_Horizontal; LCSC C20617492
JP1, JP2, JP3, JP4, JP5, JP6, JP7, JP8, JP9, JP10, JP11, JP12, JP13: Cell_shunt; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
Q1: IPT015N10N5; Infineon_PG-HSOF-8-1_ThermalVias; LCSC C108964
R15, R16, R17, R18: 5.1k; R_0402_1005Metric
R19, R21, R22: 120; R_0402_1005Metric
R20: 0.2m; R_1206_3216Metric; LCSC C42454010
R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39: 56; R_1206_3216Metric; LCSC C2933788
R40: 10M; R_0402_1005Metric
R41: 75; C_0402_1005Metric
TH1: MOS_Temp; R_0402_1005Metric
TP7: TestPoint; TestPoint_Pad_D1.0mm
U5: BQ769x2; TQFP-48_7x7mm_P0.5mm

Connections:
/Frontend/BAT+: C49.1, D1.2 (A), Q1.2 (S), R17.1, R18.1, R40.1; also elsewhere on the board
/Frontend/BAT-: R20.2, R21.2; also elsewhere on the board
/Frontend/CEL_1: J6.16, R38.2
/Frontend/CEL_2: J6.15, R37.2
/Frontend/CEL_3: J6.14, R36.2
/Frontend/CEL_4: J6.13, R35.2
/Frontend/CEL_5: J6.12, R34.2
/Frontend/CEL_6: J6.11, R33.2
/Frontend/CEL_7: J6.10, R32.2
/Frontend/CEL_8: J6.9, R31.2
/Frontend/CEL_9: J6.8, R30.2
/Frontend/CEL_10: J6.7, R29.2
/Frontend/CEL_11: J6.6, R28.2
/Frontend/CEL_12: J6.5, R27.2
/Frontend/CEL_13: J6.4, R26.2
/Frontend/CEL_14: J6.3, R25.2
/Frontend/CEL_15: J6.2, R24.2
/Frontend/CEL_16: J6.1, R22.2, R23.2
/Frontend/CHG: D1.1 (K), R40.2, R41.2, U5.45 (CHG)
/Frontend/CHG+: C50.2, Q1.3 (D); also elsewhere on the board
/Frontend/CHG-: R19.2, R20.1; also elsewhere on the board
/Frontend/DSG: U5.43 (DSG)
/Frontend/I2C_SCL: U5.26 (SCL); also elsewhere on the board
/Frontend/I2C_SDA: U5.27 (SDA); also elsewhere on the board
/Frontend/Shutdown: R15.1; also elsewhere on the board
GND: C29.1, C30.2, C31.2, C47.2, C48.2, J4.2, J4.MP (MountPin), J5.2, J5.MP (MountPin), J6.17, J6.MP (MountPin), R16.1, R39.2, TH1.2, U5.17 (VSS), U5.29 (CFETOFF), U5.30 (DFETOFF), U5.34 (REG2), U5.35 (REG1), U5.36 (REGIN), U5.37 (BREG); also elsewhere on the board
unnamed: C49.2, C50.1
unnamed: J4.1, U5.21 (TS1)
unnamed: J5.1, U5.23 (TS3)
unnamed: C45.2, C46.1, JP1.1 (A), R37.1, U5.14 (VC2)
unnamed: C44.2, C45.1, JP1.2 (B), JP3.1 (A), R36.1, U5.13 (VC3)
unnamed: C43.2, C44.1, JP2.1 (A), JP3.2 (B), R35.1, U5.12 (VC4)
unnamed: C42.2, C43.1, JP2.2 (B), JP4.1 (A), R34.1, U5.11 (VC5)
unnamed: C41.2, C42.1, JP4.2 (B), JP5.1 (A), R33.1, U5.10 (VC6)
unnamed: C40.2, C41.1, JP5.2 (B), JP6.1 (A), R32.1, U5.9 (VC7)
unnamed: C39.2, C40.1, JP6.2 (B), JP7.1 (A), R31.1, U5.8 (VC8)
unnamed: C38.2, C39.1, JP7.2 (B), JP8.1 (A), R30.1, U5.7 (VC9)
unnamed: C37.2, C38.1, JP8.2 (B), JP9.1 (A), R29.1, U5.6 (VC10)
unnamed: C36.2, C37.1, JP9.2 (B), JP10.1 (A), R28.1, U5.5 (VC11)
unnamed: C35.2, C36.1, JP10.2 (B), JP11.1 (A), R27.1, U5.4 (VC12)
unnamed: C34.2, C35.1, JP11.2 (B), JP12.1 (A), R26.1, U5.3 (VC13)
unnamed: C33.2, C34.1, JP12.2 (B), JP13.1 (A), R25.1, U5.2 (VC14)
unnamed: C32.2, C33.1, JP13.2 (B), R24.1, U5.1 (VC15)
unnamed: Q1.1 (G), R41.1
unnamed: C27.1, C30.1, C31.1, R22.1, U5.47 (BAT)
unnamed: C27.2, U5.46 (CP1)
unnamed: TH1.1, U5.28 (HDQ)
unnamed: R18.2, U5.41 (LD)
unnamed: R17.2, U5.42 (PACK)
unnamed: C29.2, U5.24 (REG18)
unnamed: R16.2, TP7.1, U5.33 (RST_SHUT)
unnamed: C28.1, R19.1, U5.20 (SRN)
unnamed: C28.2, R21.1, U5.18 (SRP)
unnamed: R15.2, U5.22 (TS2)
unnamed: C48.1, R39.1, U5.16 (VC0)
unnamed: C46.2, C47.1, R38.1, U5.15 (VC1)
unnamed: C32.1, R23.1, U5.48 (VC16)

Notes on the sheet:
Analog Frontend
Charge Enable
High side switch
AFE

Parts:
AE1: WiFi+BT; Texas_SWRA117D_2.4GHz_Left
C2, C5, C7, C13, C15: 1u; C_0402_1005Metric
C3, C9, C11: 100n; C_0402_1005Metric
C4, C6: 16p; C_0402_1005Metric
C8: 10n; C_0402_1005Metric
C10: 10u; C_0402_1005Metric
C12, C14: 1.5pF; C_0402_1005Metric; LCSC C282238
L1: 24n; L_0402_1005Metric
L2: 2n; L_0402_1005Metric
L3: 2.4n; L_0402_1005Metric; LCSC C97997
R5, R6, R7, R8, R9, R10: 5.1k; R_0402_1005Metric
TP1, TP2, TP3, TP4, TP5, TP6: TestPoint; TestPoint_Pad_D1.0mm
U2: ESP32-C3; QFN-32-1EP_5x5mm_P0.5mm_EP3.7x3.7mm_ThermalVias; LCSC C2858491
Y1: 40MHz; Crystal_SMD_2520-4Pin_2.5x2.0mm; LCSC C3007519

Connections:
+3.3V: C3.1, C5.1, C7.1, C8.1, C9.1, C10.1, C11.1, L2.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, U2.11 (VDD3P3_RTC), U2.17 (VDD3P3_CPU), U2.18 (VDD_SPI), U2.31 (VDDA), U2.32 (VDDA); also elsewhere on the board
/Frontend/I2C_SCL: R8.2, U2.27 (U0RXD); also elsewhere on the board
/Frontend/I2C_SDA: R7.2, U2.28 (U0TXD); also elsewhere on the board
/MCU/Ant_CLC: AE1.1 (A), C14.1, L3.2
/MCU/CAN_RX: U2.12 (MTCK); also elsewhere on the board
/MCU/CAN_TX: U2.13 (MTDO); also elsewhere on the board
/MCU/MCU_CLC: C12.1, L3.1, U2.1 (LNA_IN)
/MCU/VDD_RF: C13.1, L2.2, U2.2 (VDD3P3), U2.3 (VDD3P3)
/MCU/~COM_EN: C2.1, R5.2, U2.15 (GPIO9); also elsewhere on the board
/USB_DN: U2.26 (GPIO19); also elsewhere on the board
/USB_DP: U2.25 (GPIO18); also elsewhere on the board
GND: AE1.2 (Shield), C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, U2.33 (GND), Y1.2, Y1.4; also elsewhere on the board
unnamed: C6.1, L1.1, Y1.3
unnamed: C15.1, R10.2, U2.7 (CHIP_EN)
unnamed: R9.2, U2.6 (GPIO2)
unnamed: TP1.1, U2.8 (GPIO3)
unnamed: R6.2, U2.14 (GPIO8)
unnamed: TP2.1, U2.16 (GPIO10)
unnamed: TP6.1, U2.10 (MTDI)
unnamed: TP5.1, U2.9 (MTMS)
unnamed: TP4.1, U2.5 (XTAL_32K_N)
unnamed: TP3.1, U2.4 (XTAL_32K_P)
unnamed: C4.1, U2.29 (XTAL_N), Y1.1
unnamed: L1.2, U2.30 (XTAL_P)

Notes on the sheet:
VDD_SPI
VDD_CPU
WiFi + BLE
RTC
Power supply decoupling
VDDA
Microcontroller
RF power decoupling
Needed to enter in USB download mode

Parts:
C16: 2.2u; C_1206_3216Metric; LCSC C577211
C17: 100n; C_1206_3216Metric; LCSC C1945
C18, C21, C23: 1u; C_0402_1005Metric
C19: 2.2n; C_0402_1005Metric; LCSC C106861
C20: 100p; C_0603_1608Metric
C22: 1.5n; C_0603_1608Metric
C24, C25, C26: 4.7u; C_0805_2012Metric
L4: 68u; L_KOHERelec_MDA7030; LCSC C2894721
R11: 82.5k; R_0402_1005Metric
R12: 523k; R_0402_1005Metric
R13: 200k; R_0402_1005Metric
R14: 63.4k; R_0402_1005Metric
U3: LM5163DDA; HSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.1mm_ThermalVias; LCSC C2873264
U4: TPS70933; SOT-23-5; LCSC C89347

Connections:
+3.3V: C21.1, C23.1, U4.5 (OUT); also elsewhere on the board
+5V: C18.1, C22.2, C24.1, C25.1, C26.1, L4.2, R13.1, U4.1 (IN), U4.3 (EN); also elsewhere on the board
/Frontend/BAT+: C16.2, C17.1, U3.2 (VIN); also elsewhere on the board
/Frontend/Shutdown: U3.3 (EN/UVLO); also elsewhere on the board
GND: C16.1, C17.2, C18.2, C21.2, C23.2, C24.2, C25.2, C26.2, R11.2, R14.2, U3.1 (GND), U3.9 (EP), U4.2 (GND); also elsewhere on the board
unnamed: C20.1, C22.1, R12.2
unnamed: C19.1, U3.7 (BST)
unnamed: C20.2, R13.2, R14.1, U3.5 (FB)
unnamed: R11.1, U3.4 (RON)
unnamed: C19.2, L4.1, R12.1, U3.8 (SW)

Notes on the sheet:
Logic Power
5V to 3.3V LDO
Main Buck
BAT to 5V buck

Board: 4 copper layers, 90.0 x 50.0 mm, 141 parts (20 on the bottom side), 88 nets.

Other parts of the board:
kibuzzard-688328D2: G***; kibuzzard-688328D2

## Commit log

2022-07-30 Created KiCAD project
2022-07-30 Added KiCAD gitingore
2022-07-31 MCU schematics
2022-07-31 Added AFE chip symbol
2022-07-31 Connected SWD pins
2022-07-31 Define footprints
2022-07-31 Added footprints and some LCSC part numbers
2022-07-31 Cleaned component fields
2022-07-31 Added bluetooth interface
2022-07-31 Communication interfaces
2022-07-31 README file
2022-07-31 updated docs
2022-07-31 Discord invite link
2022-07-31 Typo
2022-07-31 Docs update
2022-07-31 BLE module
2022-07-31 Some work on Battery AFE and PSU
2022-07-31 Balance frontend
2022-07-31 Analog front end daisy chain
2022-07-31 tidy up schematics
2022-07-31 Analog front end ready
2022-08-01 AFE SPI
2022-08-01 Status LEDs
2022-08-01 NTC sensors
2022-08-01 Fix schematic
2022-08-01 Tidy up schematic
2022-08-01 Change project name
2022-08-01 added links to VESC BMS repository
2022-08-02 Credits section
2022-08-02 Docs improvement
2022-08-02 Annotate schematic
2022-11-10 MicroFit 3.0 for battery connector
2022-11-11 Current sensor
2023-03-20 Using KiCAD v7
2023-03-20 Update design to KiCAD v7
2023-03-20 Initial work on a block diagram
2023-03-20 DNP marks from new KiCAD
2023-03-23 Block diagram complete
2023-03-23 Added block diagram to README
2023-03-23 Added expansion header to block diagram
2023-04-08 Change Bluetooth to BLE module
2023-04-08 Thermistors filtering
2023-04-09 Add buzzer to block diagram
2023-04-24 Work on thermal
2023-04-24 Add status LEDs to block diagram
2023-04-25 AFE WDT pin
2023-04-25 Fan ports
2023-04-25 Charger monitor
2023-04-25 Initial work on High side switch
2023-04-28 Update block diagram
2023-04-28 Cleaned up block diagram
2023-04-29 Fan freewheeling
2023-04-29 Charger enable circiut and more ext NTC
2023-04-29 OLED screen
2023-04-29 Remove left over IC
2023-04-29 Improve AFE power supply filtering
2023-10-10 Charge monitor complete
2023-10-10 Total current sense and buzzer
2023-10-10 Fuse in balancing circuit
2023-12-07 Split the design into front end and controller
2023-12-13 Set IBIAS resistors for daisy chain
2023-12-13 Filter frontend input voltage
2023-12-14 Schematic finished
2023-12-14 footprints assigned
2024-01-26 Add LTC6820 symbol
2024-01-29 Current sensors and ISOSPI interface
2024-02-08 Changed back to a unified design
2024-02-08 Fix OLED pinout and add HDC1080
2024-02-09 Ignore KiCAD lock files
2024-02-09 Wire up the AFE
2024-02-09 Charger connector
2024-02-09 BAT to 12V converter
2024-02-09 Add missing files
2024-02-09 Voltage regulators
2024-02-09 Add option to power AFE from 5V on board regulator
2024-02-10 Fix some ERC issues
2024-02-11 Add MCU connections
2024-02-13 Remove BLE module to increase efficiency
2024-02-13 Assigned some footprints
2024-02-13 Fix orientation of balance FET
2024-02-13 Change LEDs to 3mm
2024-02-14 Fix AFE readability
2024-02-14 Remove old sheet
2024-02-14 Fix redability issues
2024-02-14 Add Fan interface
2024-02-15 Add switch to current sensors
2024-02-15 Replaced LDO
2024-02-15 Create LICENSE
    Fix #9
2024-02-16 Replace buck regulator
2024-02-16 Power improvements
2024-02-16 OLED
2024-02-16 OLED regulator
2024-02-18 OLED interface complete
2024-03-28 Update to KiCAD 8
2024-03-29 Added shunt amplifier
2024-03-29 Tune Charger current and MOSFET fix orientation
2024-03-29 Initiated sourcing
2024-03-29 More sourcing components
2024-03-30 Improved Currrent Sensors
2024-03-30 Charger monitoring
2024-03-30 Ongoing work on high side switch
2024-10-17 Changed MCU and AFE
2024-10-18 Thermistors
2024-10-20 Some work on AFE
2024-10-20 Remove uneeded peripherals
2024-10-20 Added LDO
2024-10-20 Updated documentation
2024-10-21 Remove differential amlifiers
2024-10-21 Connect AFE IC to Balance connector
2024-10-21 Test GitHub Actions
2024-10-22 fix bom JLC
2024-10-22 more verbosity on kibot
2024-10-22 added outline to avoid BOM generation fail
2024-10-22 try to export layout
2024-10-22 fix zip inside zip
2024-10-29 Balancing FETs
2024-10-31 Cell balancing of 32S
2024-11-04 Balancing FEts connection
2024-11-04 Level shifting for sync between top and bot AFE
2024-11-05 Current shunt shematic
2024-11-05 BAT supply
2024-11-05 Meantion where the latest version of the schematic can be found
2024-11-06 Send Schematic to Discord
2024-11-06 fix file path
2024-11-06 Only generate Schematic on Schematic changes
2024-11-06 fix GitHub Actions
2024-11-06 Run CI also if PCB changes
2024-11-06 Send PCB and Schematic to discord if changes are made individually
2024-11-06 Test Schematic change
2024-11-06 Fix GitHub action
2024-11-06 Fix CI
2024-11-06 CI multiple files upload
2024-11-06 Test Schematic edit
2024-11-06 CI fix PCB upload
2024-11-06 Test Shematic update
2024-11-06 Add debugging info to CI
2024-11-06 Test Shematic change
2024-11-07 Send to Discord PCB and Schematic if there is a change in either one
2024-11-07 Update generate-gerbers.yaml
    Instead of uploading the directory labeled as a .zip file, upload it as a normal artifact excluding the PDF files which are uploaded seperately
2024-11-07 test new workflow
2024-11-07 Update generate-gerbers.yaml
    Accidentally forgot to invert this, oops
2024-11-13 I2C pwoer switch
2024-11-20 CHG and DSH circuitry
2024-11-20 Connectors
2024-11-22 Fix Voltage supply of AFEs
2025-03-10 Update to KiCAD 9
2025-03-10 Simplified AFE
2025-03-11 Test CI
2025-03-11 Revert "Fix CI"
    This reverts commit 2ed332ad77608375af669dbbad6183d480b8686f.
2025-03-11 Try to fix CI
2025-03-11 Revert "Try to fix CI"
    This reverts commit 08277d88bbd0e7b7452582605256cebde2a0fcd5.
2025-03-11 Try a dev version of KiCAD automation scripts
2025-03-11 Reanotate
2025-03-11 Reorder Schematic pages
2025-03-11 Change discharge current
2025-03-12 MCU pinning
2025-03-13 Remove Thermal reliefs from connectors MP and ESP32 Crystal
2025-03-13 Crystal Layout
2025-03-13 Increased Discharge Resistor size
2025-03-13 Cell balancing sourcing and repositioning
2025-03-15 Various changes (can't remember)
2025-03-15 Choose MOSFET
2025-03-16 Increased spec for 32S
2025-03-17 Layout test
2025-03-17 Update Schematic
2025-03-17 Charge and Discharge FETs
2025-03-17 FET layout study
2025-03-19 Change to stable version of CI container now that it is relased
2025-03-24 ESP32 Decoupling
2025-03-26 RF Inductor sourcing
2025-03-26 MCU circuit sourced complete
2025-03-28 Update LICENSE
2025-04-10 Thermistor conenctions
2025-04-10 NTCs
2025-04-10 Fix NTC connection
2025-04-10 Charge and DSH
2025-04-11 gate drivers open to be defined
2025-04-14 Reduce to 16S for now
2025-04-15 LDO changed to a low Iq
2025-04-15 CAN transciever
2025-04-16 IO reorganization
2025-04-16 decouple EN switch
2025-04-16 AFE Schematic
2025-04-16 Fix Schematic generated by CI
2025-04-16 Add missing cell conection
2025-04-16 Change balancing to a unified connector
2025-04-16 Fix footprint library path
2025-04-16 Remove old parts from footprint library
2025-04-16 Add balance connector to footprint library
2025-04-16 Change balance current and set most of the footprints
2025-04-16 Initial layout placement study
2025-04-16 Cleanup ERC errors
2025-04-16 Connectors changed to JST GH
2025-04-17 Prettyfy Schematic
2025-04-17 Add resistor to discharge load switches gates
2025-04-17 Reanotate schematic
2025-04-18 Improvements to main buck and load switch
2025-04-18 Update PCB
2025-04-23 Enable logic
2025-04-29 Cell to BAT connection
2025-04-29 Automotive fuse
2025-04-30 BAT- to GND connection
2025-06-14 BAT connector change
2025-06-14 GND moved to PACK-
2025-06-14 Replace Front end input diode for a Schotky
2025-06-14 package sizes set and AFE layout
2025-06-14 Change MCU footprint to GND vias on EPAD
2025-06-14 Install zip package on CI
2025-06-14 run apt without sudo on CI
2025-06-14 ESP32 layout
2025-06-17 Majority of layout placement done
2025-06-17 Board dimensions fix
2025-06-18 First Layout placement
2025-06-18 Improve PCB export
2025-06-18 reduce kibot verbosity
2025-06-18 Fix Silkscreeen on PCB CI export
2025-06-18 Improve PCB layout print file
2025-06-18 Also run CI automaticall ywhen CI files are edited
2025-06-18 Revert "reduce kibot verbosity"
    This reverts commit f96afd0d271b1e2fe52b92c751fd01b2e96e7d8f.
2025-06-18 Print front and back PCB layout on one PDF in two pages
2025-06-18 Fix CI file paths
2025-06-18 CI fix folder path
2025-06-18 remove redundant files
2025-06-19 heatsink interface
2025-06-19 Fix Kibot deprecations
2025-06-19 Remove U.fL connector and improve layout
2025-06-19 Remove temorary files
2025-06-19 remove references to another project
2025-06-29 Zone fills
2025-07-05 PCB work
2025-07-21 Fix connection
2025-07-25 Change product label
2025-08-02 Moved to a 4 layer board
2025-08-04 Changed to charge only BMS
