File: hardware/greenmobi-bms.kicad_sch (KiCad schematic)
At the start: 12 parts, among them J1 BAT+, J2 BAT-, J3 Conn_01x02, J4 PACK+, J5 PACK-, J6 USB_C_Receptacle_USB2.0_14P, J7 CAN, U1 TJA1042T-3

Commit message: Improvements to main buck and load switch
Other:
- sheet Power Supply ports: added EN; removed none
Changed lines of the file:
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@@
 	(wire
 		(pts
-			(xy 82.55 40.64) (xy 77.47 40.64)
-		)
-		(stroke
-			(width 0)
-			(type default)
-		)
-	)
-	(wire
-		(pts
-			(xy 77.47 40.64) (xy 77.47 59.69)
+			(xy 82.55 41.91) (xy 77.47 41.91)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
+			(xy 77.47 41.91) (xy 77.47 59.69)
 		)
 		(stroke
@@
 	(polyline
 		(pts
-			(xy 163.83 48.895) (xy 163.83 109.855)
+			(xy 163.83 49.53) (xy 163.83 109.855)
 		)
 		(stroke
@@
 		)
 		(pin "BAT" input
-			(at 82.55 40.64 180)
-			(effects
-				(font
+			(at 82.55 41.91 180)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify left)
+			)
+		)
+		(pin "EN" input
+			(at 82.55 39.37 180)
+			(effects
+				(font

Commit message: Enable logic
Parts:
- added R52: 5.1k, Resistor_SMD:R_0402_1005Metric, symbol Device:R
- J3: value Conn_01x02 -> EN; footprint Connector_PinHeader_1.00mm:PinHeader_1x02_P1.00mm_Vertical -> Connector_JST:JST_GH_SM02B-GHS-TB_1x02-1MP_P1.25mm_Horizontal
Connections:
- net +3.3V: now also R52.2
- net MCU/EN renamed Frontend/Shutdown
- net Frontend/Shutdown: now also R52.1
Other:
- sheet Frontend ports: added Shutdown; removed none
- sheet MCU ports: added none; removed EN
- note added: "Switch (key)"
- note removed: "Switch"
- moved on the sheet: C1, J3

Commit message: Automotive fuse
Parts:
- added H1, H2: Fuse, greenmobi-bms:Automotive_Fuse, symbol Mechanical:MountingHole_Pad
Connections:
- net Frontend/BAT+: now also H1.1; no longer J1.1 (Pin_1)
- new net: H2.1, J1.1 (Pin_1)
Other:
- moved on the sheet: J1
Changed lines of the file:
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@@
 	(wire
 		(pts
-			(xy 76.2 59.69) (xy 77.47 59.69)
+			(xy 29.21 59.69) (xy 34.29 59.69)
 		)
 		(stroke
@@
 		(pts
 			(xy 104.14 38.1) (xy 104.14 39.37)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
+			(xy 44.45 59.69) (xy 77.47 59.69)
 		)
 		(stroke
@@
 	(symbol
 		(lib_id "Connector_Generic:Conn_01x01")
-		(at 71.12 59.69 180)
+		(at 24.13 59.69 180)
 		(unit 1)
 		(exclude_from_sim no)
@@
 		(fields_autoplaced yes)
 		(property "Reference" "J1"
-			(at 71.12 53.34 0)
+			(at 24.13 53.34 0)
 			(effects
 				(font
@@
 		)
 		(property "Value" "BAT+"
-			(at 71.12 55.88 0)
+			(at 24.13 55.88 0)
 			(effects
 				(font
@@
 		)
 		(property "Footprint" "TestPoint:TestPoint_Pad_4.0x4.0mm"
-			(at 71.12 59.69 0)
+			(at 24.13 59.69 0)
 			(effects
 				(font
@@
 		)
 		(property "Datasheet" "~"
-			(at 71.12 59.69 0)
+			(at 24.13 59.69 0)
 			(effects
 				(font
@@
 		)
 		(property "Description" "Generic connector, single row, 01x01, script generated (kicad-library-utils/schlib/autogen/connector/)"
-			(at 71.12 59.69 0)
+			(at 24.13 59.69 0)
 			(effects
 				(font
@@
 		)
 		(property "Sim.Device" ""
-			(at 71.12 59.69 0)
+			(at 24.13 59.69 0)
 			(effects
 				(font
@@
 		)
 		(property "Sim.Pins" ""
-			(at 71.12 59.69 0)
+			(at 24.13 59.69 0)
 			(effects
 				(font
@@
 				(path "/3e668e3e-3e16-4665-a807-4735962c41d3"
 					(reference "#PWR09")
+					(unit 1)
+				)
+			)
+		)
+	)
+	(symbol
+		(lib_id "Mechanical:MountingHole_Pad")
+		(at 44.45 62.23 180)
+		(unit 1)
+		(exclude_from_sim no)
+		(in_bom no)
+		(on_board yes)
+		(dnp no)
+		(fields_autoplaced yes)
+		(property "Reference" "H1"
+			(at 46.99 62.2299 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify right)
+			)
+		)
+		(property "Value" "Fuse"
+			(at 46.99 64.7699 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify right)
+			)
+		)
+		(property "Footprint" "greenmobi-bms:Automotive_Fuse"
+			(at 44.45 62.23 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "Datasheet" "~"
+			(at 44.45 62.23 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "Description" "Mounting Hole with connection"
+			(at 44.45 62.23 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(pin "1"
+		)
+		(instances
+			(project ""
+				(path "/3e668e3e-3e16-4665-a807-4735962c41d3"
+					(reference "H1")
 					(unit 1)
 				)
@@
 					(unit 1)
 				)
+			)
+		)
+	)
+	(symbol
+		(lib_id "Mechanical:MountingHole_Pad")
+		(at 34.29 62.23 180)
+		(unit 1)
+		(exclude_from_sim no)
+		(in_bom no)
+		(on_board yes)
+		(dnp no)
+		(fields_autoplaced yes)
+		(property "Reference" "H2"
+			(at 36.83 62.2299 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify right)
+			)
+		)
+		(property "Value" "Fuse"
+			(at 36.83 64.7699 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify right)
+			)
+		)
+		(property "Footprint" "greenmobi-bms:Automotive_Fuse"
+			(at 34.29 62.23 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "Datasheet" "~"
+			(at 34.29 62.23 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "Description" "Mounting Hole with connection"
+			(at 34.29 62.23 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(pin "1"
+		)
+		(instances
+			(project "greenmobi-bms"
+				(path "/3e668e3e-3e16-4665-a807-4735962c41d3"
+					(reference "H2")
+					(unit 1)
+				)

Commit message: BAT- to GND connection
Connections:
- net Frontend/BAT- is gone; now on net GND: J2.1 (Pin_1)
- net GND: no longer J5.1 (Pin_1)
- new net Frontend/PACK-: J5.1 (Pin_1)
Changed lines of the file:
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@@
-	)
-	(junction
-		(at 106.68 69.85)
-		(diameter 0)
-		(color 0 0 0 0)
 	)
 	(junction
@@
 	)
 	(junction
+		(at 77.47 69.85)
+		(diameter 0)
+		(color 0 0 0 0)
+	)
+	(junction
 		(at 41.91 39.37)
 		(diameter 0)
@@
 	(wire
 		(pts
-			(xy 100.33 69.85) (xy 106.68 69.85)
+			(xy 100.33 69.85) (xy 109.22 69.85)
 		)
 		(stroke
@@
 	(wire
 		(pts
-			(xy 106.68 69.85) (xy 109.22 69.85)
-		)
-		(stroke
-			(width 0)
-			(type default)
-		)
-	)
-	(wire
-		(pts
 			(xy 219.71 101.6) (xy 219.71 99.06)
 		)
@@
 	(wire
 		(pts
-			(xy 76.2 69.85) (xy 82.55 69.85)
+			(xy 76.2 69.85) (xy 77.47 69.85)
 		)
 		(stroke
@@
 		(pts
 			(xy 186.69 81.28) (xy 195.58 81.28)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
+			(xy 77.47 69.85) (xy 82.55 69.85)
 		)
 		(stroke
@@
 	(symbol
 		(lib_id "power:GND")
-		(at 106.68 69.85 0)
+		(at 77.47 69.85 0)
 		(unit 1)
 		(exclude_from_sim no)
@@
 		(fields_autoplaced yes)
 		(property "Reference" "#PWR04"
-			(at 106.68 76.2 0)
+			(at 77.47 76.2 0)
 			(effects
 				(font
@@
 		)
 		(property "Value" "GND"
-			(at 106.68 74.93 0)
+			(at 77.47 74.93 0)
 			(effects
 				(font
@@
 		)
 		(property "Footprint" ""
-			(at 106.68 69.85 0)
+			(at 77.47 69.85 0)
 			(effects
 				(font
@@
 		)
 		(property "Datasheet" ""
-			(at 106.68 69.85 0)
+			(at 77.47 69.85 0)
 			(effects
 				(font
@@
 		)
 		(property "Description" "Power symbol creates a global label with name \"GND\" , ground"
-			(at 106.68 69.85 0)
-			(effects
-				(font
+			(at 77.47 69.85 0)
+			(effects
+				(font

Commit message: BAT connector change
Parts:
- removed J1: BAT+, TestPoint:TestPoint_Pad_4.0x4.0mm, symbol Connector_Generic:Conn_01x01
- removed J2: BAT-, TestPoint:TestPoint_Pad_4.0x4.0mm, symbol Connector_Generic:Conn_01x01
- removed J4: PACK+, TestPoint:TestPoint_Pad_4.0x4.0mm, symbol Connector_Generic:Conn_01x01
- removed J5: PACK-, TestPoint:TestPoint_Pad_4.0x4.0mm, symbol Connector_Generic:Conn_01x01
- added H3: BAT-, greenmobi-bms:Automotive_Fuse, symbol Mechanical:MountingHole_Pad
- added H4: PACK-, greenmobi-bms:Automotive_Fuse, symbol Mechanical:MountingHole_Pad
- added H5: PACK+, greenmobi-bms:Automotive_Fuse, symbol Mechanical:MountingHole_Pad
- H2: value Fuse -> BAT+
Connections:
- net Frontend/PACK+: now also H5.1
- net Frontend/PACK-: now also H4.1
- net GND: now also H3.1
- no-connect marks 1 -> 2
Other:
- moved on the sheet: H1, H2

Commit message: GND moved to PACK-
Connections:
- net Frontend/PACK- is gone; now on net GND: H4.1
- net GND: no longer H3.1
- new net Frontend/BAT-: H3.1
Changed lines of the file:
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@@
-	)
-	(junction
-		(at 73.66 69.85)
-		(diameter 0)
-		(color 0 0 0 0)
 	)
 	(junction
@@
 	)
 	(junction
+		(at 106.68 69.85)
+		(diameter 0)
+		(color 0 0 0 0)
+	)
+	(junction
 		(at 62.23 39.37)
 		(diameter 0)
@@
 	(wire
 		(pts
-			(xy 100.33 69.85) (xy 109.22 69.85)
+			(xy 100.33 69.85) (xy 106.68 69.85)
 		)
 		(stroke
@@
 	(wire
 		(pts
+			(xy 106.68 69.85) (xy 109.22 69.85)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 219.71 101.6) (xy 219.71 99.06)
 		)
@@
 	(wire
 		(pts
-			(xy 72.39 69.85) (xy 73.66 69.85)
+			(xy 72.39 69.85) (xy 82.55 69.85)
 		)
 		(stroke
@@
 		(pts
 			(xy 186.69 81.28) (xy 195.58 81.28)
-		)
-		(stroke
-			(width 0)
-			(type default)
-		)
-	)
-	(wire
-		(pts
-			(xy 73.66 69.85) (xy 82.55 69.85)
 		)
 		(stroke
@@
 	(symbol
 		(lib_id "power:GND")
-		(at 73.66 69.85 0)
+		(at 106.68 69.85 0)
 		(unit 1)
 		(exclude_from_sim no)
@@
 		(fields_autoplaced yes)
 		(property "Reference" "#PWR04"
-			(at 73.66 76.2 0)
+			(at 106.68 76.2 0)
 			(effects
 				(font
@@
 		)
 		(property "Value" "GND"
-			(at 73.66 74.93 0)
+			(at 106.68 74.93 0)
 			(effects
 				(font
@@
 		)
 		(property "Footprint" ""
-			(at 73.66 69.85 0)
+			(at 106.68 69.85 0)
 			(effects
 				(font
@@
 		)
 		(property "Datasheet" ""
-			(at 73.66 69.85 0)
+			(at 106.68 69.85 0)
 			(effects
 				(font
@@
 		)
 		(property "Description" "Power symbol creates a global label with name \"GND\" , ground"
-			(at 73.66 69.85 0)
-			(effects
-				(font
+			(at 106.68 69.85 0)
+			(effects
+				(font
